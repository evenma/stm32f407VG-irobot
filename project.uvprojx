# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: board;..\..\..\components\libc\compilers\common\include;packages\u8g2-official-latest\sys\rt-thread\port;packages\u8g2-official-latest\csrc;..\..\..\components\utilities\ymodem;..\..\..\components\drivers\include;packages\ota_downloader-latest;..\..\..\components\libc\posix\io\eventfd;..\..\..\libcpu\arm\cortex-m4;applications;.;packages\stm32f4_hal_driver-latest\Inc;applications\Misc;..\..\..\components\drivers\phy;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\poll;board\ports;..\..\..\components\utilities\ulog\syslog;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\utilities\ulog;..\..\..\components\drivers\include;..\..\..\components\fal\inc;packages\stm32f4_hal_driver-latest\Inc\Legacy;packages\stm32f4_cmsis_driver-latest\Include;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers\drivers;..\..\..\libcpu\arm\common;..\libraries\HAL_Drivers\drivers\drv_flash;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;applications\Peripherals;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;..\..\..\components\drivers\include;..\..\..\components\net\utest;applications\System;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\hwcrypto;..\..\..\components\drivers\smp_call;..\..\..\components\finsh;packages\CMSIS-Core-latest\Include
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    applications/System/: oled_handle.c packet_handle.c monitor.c user_action.c car_action.c
    applications/Peripherals/: uart_packet.c ir_receiver.c qmi8658.c zltech_can_motor.c wc_drv.c buzzer.c button.c ultrasonic_hc_sr04.c led.c ultrasonic_485.c
    applications/Misc/: MahonyAhrs.c print_utils.c checksum.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_rng.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_can.c drv_crypto.c drv_gpio.c drv_hard_i2c.c drv_pwm.c drv_spi.c drv_tim.c drv_usart_v2.c drv_wdt.c
    ../libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_f4.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Fal
    ../../../components/fal/src/: fal.c fal_rtt.c fal_flash.c fal_partition.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kstdio.c kerrno.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_usart.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_tim.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_lptim.c stm32f4xx_hal_adc.c stm32f4xx_hal_cec.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cortex.c
  group u8g2
    packages/u8g2-official-latest/csrc/: u8x8_cad.c u8g2_line.c u8x8_d_ssd1306_128x64_noname.c u8g2_ll_hvline.c mui.c u8x8_fonts.c u8x8_selection_list.c u8g2_fonts.c u8log.c u8g2_cleardisplay.c u8x8_message.c u8g2_arc.c u8x8_d_ssd1315_128x64_noname.c u8g2_bitmap.c u8x8_u16toa.c u8g2_intersection.c u8x8_display.c u8g2_message.c u8x8_string.c u8g2_buffer.c u8log_u8x8.c u8g2_kerning.c u8x8_capture.c u8g2_d_setup.c u8x8_setup.c mui_u8g2.c u8x8_debounce.c u8g2_box.c u8g2_selection_list.c u8x8_gpio.c u8g2_polygon.c u8g2_circle.c u8x8_byte.c u8g2_font.c u8x8_8x8.c u8g2_hvline.c u8x8_u8toa.c u8g2_input_value.c u8g2_d_memory.c u8log_u8g2.c u8g2_button.c u8x8_input_value.c u8g2_setup.c
    packages/u8g2-official-latest/sys/rt-thread/examples/: ssd1306_12864_4wire_hw_spi_example.c
    packages/u8g2-official-latest/sys/rt-thread/port/: u8g2_port.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/syslog/: syslog.c
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ymodem/: ymodem.c
